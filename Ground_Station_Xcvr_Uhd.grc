options:
  parameters:
    author: 'many: gr-digital, VE3IRR........WA1CYB'
    comment: /home/ray/prefix/gr38/share/gnuradio/themes/dark.qss
    description: Test Tarnsciever withTelemetry, AM, NBFM,WBFM,PSK31<CW-ID,Tone
    generate_options: qt_gui
    id: ground_test_transciever_rev_b
    output_language: python
    title: Ground Test Transciever
  states: {}

blocks:
- name: Const_HDR
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: Const_PLD
  id: variable_constellation
  parameters:
    const_points: digital.psk_2()[0]
    dims: '1'
    precision: '8'
    rot_sym: '2'
    soft_dec_lut: '''auto'''
    sym_map: digital.psk_2()[1]
    type: calcdist
  states: {}
- name: amp
  id: variable_qtgui_range
  parameters:
    label: Amplitude
    min_len: '2000'
    orient: Qt.Horizontal
    start: '0'
    step: '0.01'
    stop: '2'
    value: '1'
  states: {state: disabled}
- name: amp
  id: variable
  parameters:
    value: '1'
  states: {}
- name: audio_rate
  id: variable
  parameters:
    value: int(48000)
  states: {}
- name: baseband_rate
  id: variable
  parameters:
    value: int(24e3)
  states: {}
- name: center_freq
  id: variable
  parameters:
    comment: Test Frequency
    value: '441000000'
  states: {state: disabled}
- name: dec
  id: variable_cc_decoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_end: '-1'
    state_start: '0'
  states: {}
- name: dec_factor
  id: variable
  parameters:
    value: '4'
  states: {}
- name: dec_hdr
  id: variable_repetition_decoder_def
  parameters:
    framebits: hdr_format.header_nbits()
    ndim: '0'
    prob: '0.5'
    rep: rep
  states: {}
- name: dec_label
  id: variable_qtgui_label
  parameters:
    gui_hint: 1,3,1,1
    label: Dec#
    type: int
    value: dec_factor
  states: {}
- name: eb
  id: variable
  parameters:
    value: float(0.22)
  states: {}
- name: enc
  id: variable_cc_encoder_def
  parameters:
    framebits: '8000'
    k: k
    mode: fec.CC_TERMINATED
    ndim: '0'
    padding: 'False'
    polys: polys
    rate: rate
    state_start: '0'
  states: {}
- name: enc_hdr
  id: variable_repetition_encoder_def
  parameters:
    framebits: '8000'
    ndim: '0'
    rep: rep
  states: {}
- name: filt_delay
  id: variable
  parameters:
    value: int(1+(taps_per_filt-1)//2)
  states: {}
- name: freq
  id: variable_qtgui_range
  parameters:
    comment: |-
      11e9
      NWS:
      162550000
      162475000
      162525000
      162450000

      DTV Carrier
      500309441
    gui_hint: 0,0,1,1
    label: RX Frequency
    min_len: '2000'
    orient: Qt.Horizontal
    start: 25e6
    step: '1'
    stop: 2e9
    value: '162550000'
  states: {}
- name: freq_tx
  id: variable_qtgui_range
  parameters:
    comment: |-
      11e9
      NWS:
      162550000
      162475000
      162525000
      162450000

      146520000
    gui_hint: 4,0,1,1
    label: TX Frequency
    min_len: '2000'
    orient: Qt.Horizontal
    start: 25e6
    step: '10'
    stop: 6e9
    value: '1264500000'
  states: {}
- name: freq_uhd
  id: variable_qtgui_range
  parameters:
    comment: 9,0,1,1
    gui_hint: 4,2,1,1
    label: Frequency UHD
    min_len: '2000'
    orient: Qt.Horizontal
    start: 70e6
    step: '100'
    stop: 6e9
    value: 441e6*0+freq_tx+1500
  states: {state: disabled}
- name: gain
  id: variable_qtgui_range
  parameters:
    comment: Set RF Gain Max as a f(SDR type)
    gui_hint: 0,2,1,1
    label: RX Gain
    orient: Qt.Horizontal
    start: '0.0'
    step: '1.0'
    stop: '76'
    value: '60.0'
  states: {}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    comment: Set RF Gain Max as a f(SDR type)
    gui_hint: 4,1,1,1
    label: Tx Atten (Pluto)
    orient: Qt.Horizontal
    start: '0.0'
    step: '1.0'
    stop: '40'
    value: '10.0'
  states: {state: disabled}
- name: gain_tx
  id: variable_qtgui_range
  parameters:
    comment: Set RF Gain Max as a f(SDR type)
    gui_hint: 4,1,1,1
    label: Tx Gain (UHD)
    orient: Qt.Horizontal
    start: '0.0'
    step: '1.0'
    stop: '89'
    value: '50.0'
  states: {}
- name: gain_uhd
  id: variable_qtgui_range
  parameters:
    comment: 10,1,1,1
    gui_hint: 4,3,1,1
    label: gain_uhd
    orient: Qt.Horizontal
    start: '0'
    step: '1'
    stop: '71'
    value: '60'
  states: {state: disabled}
- name: hdr_format
  id: variable
  parameters:
    comment: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
    value: digital.header_format_counter(digital.packet_utils.default_access_code, 3, Const_PLD.bits_per_symbol())
  states: {}
- name: k
  id: variable
  parameters:
    value: '7'
  states: {}
- name: lsb_taps
  id: variable_band_pass_filter_taps
  parameters:
    gain: '1.0'
    high_cutoff_freq: 2.5e3
    low_cutoff_freq: '10'
    samp_rate: baseband_rate
    type: band_pass
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: mode
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 1,1,1,1
    label: Demodulation Type
    label0: AM(SYNC)
    label1: Band limited WBFM
    label2: USB
    label3: LSB
    label4: NBFM
    num_opts: '5'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    option4: '4'
    orient: Qt.QHBoxLayout
    type: int
    value: '4'
    widget: radio_buttons
  states: {}
- name: mode_all
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: 5,0,1,1
    label: All - AM, USB LSB,NBFM,WBFM
    'true': '1'
    type: int
    value: '0'
  states: {}
- name: mode_lin_tx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,1,1,1
    label: Linear Modulation
    label0: None
    label1: AM
    label2: USB
    label3: LSB
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: mode_nlin_tx
  id: variable_qtgui_chooser
  parameters:
    gui_hint: 5,2,1,1
    label: 'non-Linear Modulation '
    label0: None
    label1: NBFM
    label2: WBFM
    label3: Telemerty
    num_opts: '4'
    option0: '0'
    option1: '1'
    option2: '2'
    option3: '3'
    orient: Qt.QHBoxLayout
    type: int
    value: '0'
    widget: radio_buttons
  states: {}
- name: nfilts
  id: variable
  parameters:
    value: int(32)
  states: {}
- name: polys
  id: variable
  parameters:
    value: '[109, 79]'
  states: {}
- name: probe_variable
  id: variable_function_probe
  parameters:
    block_id: probe_signal
    function_name: level
    poll_rate: '35'
    value: '0'
  states: {}
- name: rate
  id: variable
  parameters:
    value: int(2)
  states: {}
- name: rep
  id: variable
  parameters:
    value: int(1)
  states: {}
- name: rit
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,1,1,1
    label: Fine Tune
    min_len: '2000'
    orient: Qt.Horizontal
    start: '-5000'
    step: '1'
    stop: '5000'
    value: '+550'
  states: {}
- name: rx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 11*sps*nfilts
    samp_rate: nfilts*sps
    sym_rate: '1.0'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    comment: |-
      (48e3)*3*4*2*2
      (24e3)*3*4*2*2*2
    value: (48e3)*3*4*2*dec_factor
  states: {}
- name: samp_rate_0
  id: variable
  parameters:
    comment: |-
      int(48e3*32) =   1.536e6

      2*2048e3+1024e3    = 5.12e6

      (2*2048e3+1024e3)*1+int(48e3*32)*0
    value: int(48e3*48*3/2)*0+int(samp_rate/2)
  states: {}
- name: samp_rate_tx
  id: variable
  parameters:
    value: int(48e3*24)*2*0+int(samp_rate)
  states: {}
- name: sps
  id: variable
  parameters:
    value: int(2)
  states: {}
- name: taps_per_filt
  id: variable
  parameters:
    value: len(psf_taps)/nfilts
  states: {}
- name: tx_rrc_taps
  id: variable_rrc_filter_taps
  parameters:
    alpha: eb
    gain: nfilts
    ntaps: 5*sps*nfilts
    samp_rate: nfilts
    sym_rate: '1.0'
  states: {}
- name: uri
  id: variable
  parameters:
    value: '''usb:3.2.5'''
  states: {}
- name: volume
  id: variable_qtgui_range
  parameters:
    gui_hint: 0,3,1,1
    label: Volume
    orient: Qt.Horizontal
    start: '0.0'
    step: '0.025'
    stop: '1.0'
    value: '0.1'
  states: {}
- name: analog_agc2_xx_0
  id: analog_agc2_xx
  parameters:
    attack_rate: '1e-1'
    decay_rate: '1e-2'
    gain: '1.0'
    max_gain: '65536'
    reference: '1.0'
    type: complex
  states: {state: disabled}
- name: analog_agc_xx_0
  id: analog_agc_xx
  parameters:
    gain: '1.0'
    max_gain: 1.0e10
    rate: '1e-3'
    reference: '0.300'
    type: complex
  states: {}
- name: analog_const_source_x_0
  id: analog_const_source_x
  parameters:
    const: '0'
    type: float
  states: {}
- name: analog_const_source_x_1
  id: analog_const_source_x
  parameters:
    const: probe_variable
    type: float
  states: {}
- name: analog_nbfm_rx_0
  id: analog_nbfm_rx
  parameters:
    audio_rate: '24000'
    comment: |-
      assuming 300->3000 pre-emphasis
      Tau = 1/(2*PI*300) = 5.30516476973e-4


      2*(3.75+5.5)= 18.5 kHz
      2*(3.75+7.5)= 22.5 kHz

      7.5 max deviations compensates for being off frequency on the uplink
    max_dev: 5e3
    quad_rate: '24000'
    tau: '5.305e-4'
  states: {}
- name: analog_nbfm_tx_0
  id: analog_nbfm_tx
  parameters:
    audio_rate: audio_rate
    comment: |-
      assuming 300->3000 pre-emphasis
      Tau = 1/(2*PI*300) = 5.30516476973e-4
    fh: '-1.0'
    max_dev: 5e3
    quad_rate: audio_rate
    tau: '5.30516e-3'
  states: {}
- name: analog_pll_refout_cc_0_0
  id: analog_pll_refout_cc
  parameters:
    max_freq: (10*2*3.14159)/baseband_rate
    min_freq: (-10*2*3.14159)/baseband_rate
    w: 3.14159/200
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-67e3/1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0
  id: analog_sig_source_x
  parameters:
    amp: 1/1
    freq: '-30e3/1'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_0_0_0
  id: analog_sig_source_x
  parameters:
    amp: 1/1
    freq: +750e3/1
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_1
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-300e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_2
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: +5e3
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3
  id: analog_sig_source_x
  parameters:
    amp: 1.8/1
    freq: '-3e3'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_3_0
  id: analog_sig_source_x
  parameters:
    amp: 1.8/1
    freq: '-8e3'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_4
  id: analog_sig_source_x
  parameters:
    amp: '1'
    freq: '-15e3'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate_tx
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_5
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 1 if cw_on else 0
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_6
  id: analog_sig_source_x
  parameters:
    amp: '1'
    comment: 1 if psk_on else 0
    freq: '-3e3'
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_sig_source_x_6_0
  id: analog_sig_source_x
  parameters:
    amp: 1/1
    comment: 1 if psk_on else 0
    freq: 5e3
    offset: '0'
    phase: '0'
    samp_rate: audio_rate
    type: complex
    waveform: analog.GR_COS_WAVE
  states: {}
- name: analog_wfm_rcv_0
  id: analog_wfm_rcv
  parameters:
    audio_decimation: int((samp_rate/dec_factor)/baseband_rate)
    comment: Set up for audio at 20 kHz or 24 kHz
    quad_rate: samp_rate/dec_factor
  states: {}
- name: analog_wfm_tx_0
  id: analog_wfm_tx
  parameters:
    audio_rate: audio_rate
    fh: '-1.0'
    max_dev: '150000'
    quad_rate: audio_rate * 8
    tau: '75e-6'
  states: {}
- name: audio_sink_0_0
  id: audio_sink
  parameters:
    samp_rate: '48000'
  states: {}
- name: band_pass_filter_0
  id: band_pass_filter
  parameters:
    comment: AM Syncronus
    decim: '1'
    gain: '1'
    high_cutoff_freq: baseband_rate/2.5
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_fff
    width: '60'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_0
  id: band_pass_filter
  parameters:
    comment: AM Envelope
    decim: '1'
    gain: '1'
    high_cutoff_freq: baseband_rate/2.5
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_fff
    width: '60'
    win: firdes.WIN_HAMMING
  states: {state: disabled}
- name: band_pass_filter_0_0_0
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '-200'
    interp: '1'
    low_cutoff_freq: '-3200'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_1
  id: band_pass_filter
  parameters:
    gain: '10'
    high_cutoff_freq: '3200'
    interp: '1'
    low_cutoff_freq: '200'
    samp_rate: audio_rate
    type: interp_fir_filter_ccc
    width: '200'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_0_2
  id: band_pass_filter
  parameters:
    comment: AM Syncronus
    decim: '1'
    gain: '1'
    high_cutoff_freq: baseband_rate/6
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_fff
    width: '60'
    win: firdes.WIN_HAMMING
  states: {state: bypassed}
- name: band_pass_filter_1
  id: band_pass_filter
  parameters:
    comment: USB  Tuned on Frequency
    decim: '1'
    gain: '1'
    high_cutoff_freq: 2.5e3
    low_cutoff_freq: '10'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: '-20'
    low_cutoff_freq: '-3.2e3'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '15'
    win: firdes.WIN_HAMMING
  states: {}
- name: band_pass_filter_2_0
  id: band_pass_filter
  parameters:
    decim: '1'
    gain: '1'
    high_cutoff_freq: 3.2e3
    low_cutoff_freq: '20'
    samp_rate: baseband_rate
    type: fir_filter_ccc
    width: '15'
    win: firdes.WIN_HAMMING
  states: {}
- name: blocks_add_const_vxx_0
  id: blocks_add_const_vxx
  parameters:
    const: '0.5'
    type: complex
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    num_inputs: '5'
    type: complex
  states: {}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {}
- name: blocks_add_xx_1_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_1_0_0
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_add_xx_2
  id: blocks_add_xx
  parameters:
    num_inputs: '3'
    type: complex
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_real_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_0_0
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_complex_to_real_2
  id: blocks_complex_to_real
  parameters: {}
  states: {}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/ray/Desktop/ray_1mb_out_txrx.txt
    type: byte
  states: {}
- name: blocks_file_source_0_4_0
  id: blocks_file_source
  parameters:
    file: /home/ray/Desktop/New Ground Station - Xcvr/ray_1mb_in.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_file_source_1_0
  id: blocks_file_source
  parameters:
    comment: This is for GS Testing.. Use other root file normally
    file: /home/ray/Desktop/New Ground Station - Xcvr/Modes/id_msg.vec
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_file_source_1_0_0
  id: blocks_file_source
  parameters:
    comment: |-
      WA1CYB
      This is for GS Testing.. Use other root file normally
    file: /home/ray/Desktop/New Ground Station - Xcvr/Flow Graphs/PSK31 binary data source file.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: int(1600*8)
    type: byte
  states: {state: bypassed}
- name: blocks_integrate_xx_0
  id: blocks_integrate_xx
  parameters:
    decim: '2500'
    type: float
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_multiply_const_vxx_0
  id: blocks_multiply_const_vxx
  parameters:
    const: volume
    type: float
  states: {}
- name: blocks_multiply_const_vxx_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: mode_all
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_0_0_0
  id: blocks_multiply_const_vxx
  parameters:
    const: amp
    type: complex
  states: {}
- name: blocks_multiply_const_vxx_1
  id: blocks_multiply_const_vxx
  parameters:
    const: '1'
    type: float
  states: {}
- name: blocks_multiply_const_vxx_2
  id: blocks_multiply_const_vxx
  parameters:
    const: '.07'
    type: complex
  states: {}
- name: blocks_multiply_const_xx_1
  id: blocks_multiply_const_xx
  parameters:
    const: '1'
    type: complex
  states: {}
- name: blocks_multiply_xx_0
  id: blocks_multiply_xx
  parameters:
    comment: carrier added
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_0_0_0_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_1
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_2
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_3_0
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_4
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_5
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_multiply_xx_6
  id: blocks_multiply_xx
  parameters:
    type: complex
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    comment: RX_power_offset_dB
    k: '-132+76'
    n: '10'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_0_0
  id: blocks_null_sink
  parameters:
    type: byte
  states: {state: disabled}
- name: blocks_null_sink_1
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_sink_2
  id: blocks_null_sink
  parameters:
    type: float
  states: {}
- name: blocks_null_sink_3
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_4
  id: blocks_null_sink
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_sink_5
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_0_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_1
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_1_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_2
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_3
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_null_source_4
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: blocks_null_source_5
  id: blocks_null_source
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_1
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_probe_rate_0
  id: blocks_probe_rate
  parameters:
    alpha: '0.15'
    mintime: '500.0'
    type: complex
  states: {state: disabled}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: hdr_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repack_bits_bb_0_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_MSB_FIRST
    k: '8'
    l: pld_const.bits_per_symbol()
    len_tag_key: packet_len
  states: {}
- name: blocks_repeat_1
  id: blocks_repeat
  parameters:
    comment: |-
      6=~ 5wpm
      3=~ 13 wpm
      12=~2 wpm
    interp: int(3)
    type: complex
  states: {}
- name: blocks_selector_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mode
    num_inputs: '5'
    num_outputs: '1'
    output_index: '0'
    type: float
  states: {}
- name: blocks_selector_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mode_lin_tx
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_selector_0_0_0
  id: blocks_selector
  parameters:
    enabled: 'True'
    input_index: mode_nlin_tx
    num_inputs: '4'
    num_outputs: '1'
    output_index: '0'
    type: complex
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: int(1600/8)
    type: byte
  states: {}
- name: blocks_tagged_stream_multiply_length_0
  id: blocks_tagged_stream_multiply_length
  parameters:
    c: sps
    lengthtagname: packet_len
    type: complex
  states: {}
- name: blocks_tagged_stream_mux_0
  id: blocks_tagged_stream_mux
  parameters:
    lengthtagname: '"packet_len"'
    ninputs: '2'
    type: complex
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: 50*samp_rate_tx
    type: complex
  states: {}
- name: blocks_throttle_1
  id: blocks_throttle
  parameters:
    samples_per_second: 20*samp_rate_tx
    type: complex
  states: {state: disabled}
- name: blocks_throttle_1_0
  id: blocks_throttle
  parameters:
    comment: |-
      1 mByte file source
      .91 gave underruns at 5.12 MHz samp_rate
      .95 gave 999.8 of 1000
      .96 gave 998.4
      1.0 didn't send all data 959.8 of 1000
    samples_per_second: 0.95*samp_rate_0/8/sps/2
    type: byte
  states: {}
- name: blocks_unpacked_to_packed_xx_0
  id: blocks_unpacked_to_packed_xx
  parameters:
    bits_per_chunk: '1'
    endianness: gr.GR_MSB_FIRST
    type: byte
  states: {}
- name: blocks_vector_source_x_2
  id: blocks_vector_source_x
  parameters:
    comment: VE3IRR
    repeat: 'True'
    type: byte
    vector: (0,0, 1,1,0,1,1,0,1, 0,0, 1,0,1,0,1,1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,0,1, 0,0, 1,0,1,1,1, 0,0, 1, 0,0, 1,1,0,1,1,0,1,0,1, 0,0, 1,1,1,0,1,1,1, 0,0, 1,1,1,1,1,1,1,1, 0,0, 1,1,1,1,1,1,1, 0,0, 1,0,1,0,1,1,1,1, 0,0, 1,0,1,0,1,1,1,1, 0,0, 1, 0,0, 1,0,1, 0,0, 1,1, 0,0, 1,0,1,1,1, 0,0, 1,0,1, 0,0, 1,1,0,1, 0,0, 1,1,1,1, 0,0, 1,0,1,1,0,1,1, 0,0, 1,0,1,0,1,1,1, 0,0, 1,1,1,0,1)
  states: {state: disabled}
- name: blocks_wavfile_sink_0_0
  id: blocks_wavfile_sink
  parameters:
    bits_per_sample: '8'
    file: C:\Ham Radio\AMSAT Lunar Mission Heimdallr\GNU Stuff\junk_wav.wav
    samp_rate: '48000'
  states: {state: disabled}
- name: blocks_wavfile_source_0
  id: blocks_wavfile_source
  parameters:
    comment: 48K audio Source
    file: /home/ray/Desktop/New Ground Station - Xcvr/Testing_WA1CYB48.wav
    repeat: 'True'
  states: {}
- name: dc_blocker_xx_0
  id: dc_blocker_xx
  parameters:
    length: '1024'
    long_form: 'True'
    type: cc
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    alias: burst_shaper_a
    insert_phasing: 'True'
    length_tag_name: packet_len
    post_padding: filt_delay
    pre_padding: '0'
    type: complex
    window: firdes.window(firdes.WIN_HANN, 20, 0)
  states: {}
- name: digital_chunks_to_symbols_xx_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: hdr_const.points()
  states: {}
- name: digital_chunks_to_symbols_xx_0_0
  id: digital_chunks_to_symbols_xx
  parameters:
    dimension: '1'
    in_type: byte
    out_type: complex
    symbol_table: pld_const.points()
  states: {}
- name: digital_crc32_async_bb_1
  id: digital_crc32_async_bb
  parameters:
    check: 'False'
  states: {}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: '[1,0]'
  states: {}
- name: digital_map_bb_1
  id: digital_map_bb
  parameters:
    map: hdr_const.pre_diff_code()
  states: {}
- name: digital_map_bb_1_0
  id: digital_map_bb
  parameters:
    map: pld_const.pre_diff_code()
  states: {}
- name: digital_protocol_formatter_async_0
  id: digital_protocol_formatter_async
  parameters:
    comment: digital.header_format_default(digital.packet_utils.default_access_code, 0)
    format: hdr_format
  states: {}
- name: digital_psk_mod_0
  id: digital_psk_mod
  parameters:
    constellation_points: '2'
    differential: 'True'
    excess_bw: '0.35'
    mod_code: '"none"'
    samples_per_symbol: '8'
  states: {}
- name: fec_async_encoder_0
  id: fec_async_encoder
  parameters:
    encoder: enc
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: fec_async_encoder_0_0
  id: fec_async_encoder
  parameters:
    encoder: enc_hdr
    mtu: '1500'
    packed: 'True'
    rev_pack: 'False'
    rev_unpack: 'False'
  states: {}
- name: freq_xlating_fir_filter_xxx_0
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: '-2.5e3'
    comment: LSB  Tuned 2.5 kHz low in Frequency
    decim: '1'
    samp_rate: baseband_rate
    taps: lsb_taps
    type: ccc
  states: {}
- name: freq_xlating_fir_filter_xxx_1
  id: freq_xlating_fir_filter_xxx
  parameters:
    center_freq: rit
    decim: '1'
    samp_rate: baseband_rate
    taps: '[1.0]'
    type: ccc
  states: {}
- name: hdr_const
  id: parameter
  parameters:
    label: Header constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: gain_tx
    auto_filter: 'True'
    bandwidth: '2200000'
    buffer_size: '32768'
    comment: |-
      run:
      iio_attr -a -d to get context
    cyclic: 'False'
    frequency: int(freq_tx)
    samplerate: int(samp_rate_tx/1)
    uri: uri
  states: {state: disabled}
- name: iio_pluto_source_0
  id: iio_pluto_source
  parameters:
    auto_filter: 'True'
    bandwidth: int(samp_rate/1)
    bbdc: 'True'
    buffer_size: '32768'
    comment: |-
      ip:192.168.2.1
      'usb:3.6.5'

      run:
      iio_attr -a -d to get context
    frequency: int(freq+rit)
    gain1: '''manual'''
    manual_gain1: gain
    quadrature: 'True'
    rfdc: 'True'
    samplerate: int(samp_rate/1)
    uri: uri
  states: {state: disabled}
- name: low_pass_filter_0
  id: low_pass_filter
  parameters:
    cutoff_freq: 100e3
    decim: dec_factor*1
    gain: '1'
    samp_rate: samp_rate/1
    type: fir_filter_ccf
    width: 10e3
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_0_0
  id: low_pass_filter
  parameters:
    cutoff_freq: (dec_factor/8)*1.4e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_0/1
    type: fir_filter_ccf
    width: 1e5
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1
  id: low_pass_filter
  parameters:
    cutoff_freq: 3.2e3
    decim: int((samp_rate/dec_factor)/baseband_rate)
    gain: '1'
    samp_rate: samp_rate/dec_factor
    type: fir_filter_ccf
    width: '100'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_1_0
  id: low_pass_filter
  parameters:
    cutoff_freq: '4000'
    gain: '2.'
    interp: '1'
    samp_rate: audio_rate
    type: interp_fir_filter_ccf
    width: '500'
    win: firdes.WIN_HAMMING
  states: {}
- name: low_pass_filter_2
  id: low_pass_filter
  parameters:
    cutoff_freq: 1.5e6
    decim: '1'
    gain: '1'
    samp_rate: samp_rate_tx
    type: fir_filter_ccf
    width: .2e6
    win: firdes.WIN_BLACKMAN
  states: {}
- name: mmse_resampler_xx_0
  id: mmse_resampler_xx
  parameters:
    comment: |-
      0.917*

      0.917*baseband_rate/48e3
    phase_shift: '0'
    resamp_ratio: baseband_rate/48e3
    type: float
  states: {state: disabled}
- name: mod_header
  id: virtual_sink
  parameters:
    stream_id: Mod Header
  states: {}
- name: mod_payload
  id: virtual_sink
  parameters:
    stream_id: Mod Payload
  states: {}
- name: note_0
  id: note
  parameters:
    note: Receiver
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: AM
  states: {}
- name: note_1
  id: note
  parameters:
    note: LSB
  states: {}
- name: note_1_0
  id: note
  parameters:
    note: USB
  states: {}
- name: note_1_0_0
  id: note
  parameters:
    note: USB
  states: {}
- name: note_1_1
  id: note
  parameters:
    note: LSB
  states: {}
- name: note_1_1_0
  id: note
  parameters:
    note: NBFM
  states: {}
- name: note_1_1_0_0
  id: note
  parameters:
    comment: (good for audio)
    note: WBFM - with Limited Bandwidth
  states: {}
- name: note_1_2
  id: note
  parameters:
    note: Upper sideband
  states: {}
- name: note_2
  id: note
  parameters:
    note: AM(ENV)
  states: {state: disabled}
- name: note_2_0
  id: note
  parameters:
    note: AM(Syncronous)
  states: {}
- name: note_2_1
  id: note
  parameters:
    note: Lower sideband
  states: {}
- name: note_3
  id: note
  parameters:
    note: ~ S meter
  states: {}
- name: note_3_0
  id: note
  parameters:
    note: Wideband FM
  states: {}
- name: note_4
  id: note
  parameters:
    note: Narrowband FM
  states: {}
- name: note_5
  id: note
  parameters:
    note: PSK31
  states: {}
- name: note_6
  id: note
  parameters:
    note: CW
  states: {}
- name: note_7
  id: note
  parameters:
    note: Now @ sample_rate_tx
  states: {}
- name: note_8
  id: note
  parameters:
    note: NBFM Rcv 24Ksps
  states: {}
- name: note_9
  id: note
  parameters:
    comment: |-
      Modification of GR-Digital

      Rate set by Variable Sample_rate_0

      Throttle is bytes/sec
      4.096 Msps => 121.6k => ~972.8 kbps

      Throttle is bytes/sec
      4.608Msps => 136.8k => ~1094.4kbps
    note: Telemetry
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    args: ''
    bb_gain0: '20'
    freq0: center_freq
    gain0: gain
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {state: disabled}
- name: packet_rx_0
  id: packet_rx
  parameters:
    eb: eb
    hdr_const: Const_HDR
    hdr_dec: dec_hdr
    hdr_format: hdr_format
    pld_const: Const_PLD
    pld_dec: dec
    psf_taps: rx_rrc_taps
    sps: sps
  states: {}
- name: pfb_arb_resampler_xxx_0
  id: pfb_arb_resampler_xxx
  parameters:
    atten: '100'
    nfilts: nfilts
    rrate: sps
    samp_delay: filt_delay
    taps: tx_rrc_taps
    type: ccf
  states: {}
- name: pld_const
  id: parameter
  parameters:
    label: Payload constellation
    value: digital.constellation_calcdist((digital.psk_2()[0]), (digital.psk_2()[1]), 2, 1).base()
  states: {}
- name: probe_signal
  id: blocks_probe_signal_x
  parameters:
    type: float
  states: {}
- name: psf_taps
  id: parameter
  parameters:
    label: Pulse Shape Filter
    value: '[0,]'
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    gui_hint: 10,2,1,2
    size: '1024'
    tr_tag: packet_len
    type: complex
  states: {state: disabled}
- name: qtgui_const_sink_x_0_0_0
  id: qtgui_const_sink_x
  parameters:
    comment: 11,0,1,2
    gui_hint: 7,2,1,2
    legend: 'False'
    name: '"Packet RX"'
    size: '800'
    type: complex
    update_time: '0.50'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: '0'
    comment: samp_rate_tx
    fc: freq+rit
    fftsize: '2048'
    grid: 'True'
    gui_hint: 2,0,1,4
    legend: 'False'
    name: '"Received Spectrum"'
    type: complex
    update_time: '0.20'
    wintype: firdes.WIN_HANN
    ymax: '-20'
    ymin: '-100'
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    comment: 11,2,1,2
    fc: '0'
    fftsize: '1024'
    gui_hint: 7,2,1,2
    legend: 'False'
    showports: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_freq_sink_x_0_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_0
    fc: '0'
    fftsize: '1024'
    grid: 'True'
    gui_hint: 7,0,1,2
    label1: Output
    name: '"Telemetry Packet Transmit"'
    showports: 'True'
    type: complex
    update_time: '0.20'
    wintype: firdes.WIN_BLACKMAN_hARRIS
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_freq_sink_x_2
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate_tx
    color1: '"red"'
    comment: 1024*16-1
    fc: freq_tx*1
    fftsize: (1024*16-1)*1+4096*0
    grid: 'True'
    gui_hint: 3,0,1,4
    legend: 'False'
    name: '"Transmit UHD"'
    type: complex
    update_time: '0.30'
    width1: '2'
    wintype: firdes.WIN_HANN
    ymax: '0'
    ymin: '-90'
  states: {}
- name: qtgui_number_sink_0
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    gui_hint: 1,0,1,1
    label1: S Meter
    max: '0'
    min: '-174+40+64'
    name: ''
    type: float
    unit1: '>4.6kHz BW  dB relative'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq+rit
    fftsize: '2048'
    gui_hint: 5,0,1,4
    name: ''
    plotconst: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate_tx
    comment: 8,0,1,4
    fc: freq_tx*1
    fftsize: 1024*8
    gui_hint: 4,2,1,2
    name: '"Transmit Pluto"'
    plotconst: 'False'
    showrf: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    ctrlpanel: 'True'
    grid: 'True'
    gui_hint: tab0@2
    label1: ''
    label2: ''
    legend: 'False'
    size: '2500'
    srate: samp_rate
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: packet_len
    type: complex
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_0
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 5,0,1,3
    label1: ''
    label2: ''
    legend: 'False'
    name: '"Header"'
    size: 1250*2
    srate: samp_rate
    tr_delay: '50'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"corr_est"'
    type: complex
    ylabel: Correlation
    ymax: '25'
    ymin: '-25'
  states: {state: disabled}
- name: qtgui_time_sink_x_1_0_0_1
  id: qtgui_time_sink_x
  parameters:
    gui_hint: tab1@2
    label1: ''
    label2: ''
    legend: 'False'
    marker1: '0'
    name: '"Payload"'
    size: '1600'
    srate: samp_rate
    style1: '3'
    tr_delay: '25'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"payload symbols"'
    type: complex
    update_time: '0.1'
    ymax: '2'
    ymin: '-2'
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: 8*audio_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_1
  id: rational_resampler_xxx
  parameters:
    decim: '24000'
    interp: '48000'
    taps: ''
    type: fff
  states: {state: disabled}
- name: rational_resampler_xxx_2
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_2_0_0_0_0_0
  id: rational_resampler_xxx
  parameters:
    decim: audio_rate
    interp: samp_rate_tx
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_3
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '192'
    taps: ''
    type: ccc
  states: {}
- name: rational_resampler_xxx_4
  id: rational_resampler_xxx
  parameters:
    decim: '2'
    interp: '1'
    taps: ''
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_5
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: fff
  states: {}
- name: rational_resampler_xxx_6
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '2'
    taps: ''
    type: ccc
  states: {}
- name: root_raised_cosine_filter_0
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: root_raised_cosine_filter_1
  id: root_raised_cosine_filter
  parameters:
    alpha: '0.35'
    decim: '1'
    gain: '1'
    ntaps: '200'
    samp_rate: audio_rate
    sym_rate: '5'
    type: fir_filter_ccf
  states: {}
- name: rtlsdr_source_0
  id: rtlsdr_source
  parameters:
    bb_gain0: '20'
    corr0: '1'
    freq0: freq+rit
    gain0: gain
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: 3*(384e3)
    sync: sync
    type: fc32
  states: {state: disabled}
- name: rx_mod_header
  id: virtual_source
  parameters:
    stream_id: Mod Header
  states: {}
- name: rx_mod_payload
  id: virtual_source
  parameters:
    stream_id: Mod Payload
  states: {}
- name: soapy_source_0
  id: soapy_source
  parameters:
    balance0: '0'
    center_freq0: freq
    comment: grc 3.8.2 Soapy appears not to function.. (installed with pybombs)
    correction0: '0'
    dc_offset0: '0'
    dc_removal0: 'True'
    devname: rtlsdr
    overall_gain0: gain
    samp_rate: samp_rate
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: freq_uhd
    comment: |-
      51.2e6 Clock with same results

      "find_all=1"
    dev_addr: '"find_all=1"'
    dev_args: '""'
    gain0: gain_uhd
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_0
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: uhd_usrp_sink_0_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    bw0: 3e6*0+samp_rate_tx*0
    center_freq0: freq_tx
    comment: |-
      51.2e6 Clock with same results

      "find_all=1"
    dev_addr: '"find_all=1"'
    dev_args: '""'
    gain0: gain_tx
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate_tx
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: freq+rit
    clock_rate: '0.0'
    dc_offs_enb0: '""'
    dev_addr: ''
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sd_spec0: A:A
    sync: pc_clock
    type: fc32
  states: {}
- name: uhd_usrp_source_0_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    bw0: 3e6
    center_freq0: freq
    comment: |-
      DEVICE ADDRESS:
      "addr=192.168.0.8"
      "find_all=1"
    dc_offs_enb0: '""'
    dev_addr: '"find_all=1"'
    dev_args: '""'
    gain0: gain
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: pc_clock
    type: fc32
  states: {state: disabled}
- name: virtual_sink_0
  id: virtual_sink
  parameters:
    stream_id: rit_agc
  states: {}
- name: virtual_sink_0_0
  id: virtual_sink
  parameters:
    stream_id: probe
  states: {}
- name: virtual_source_0
  id: virtual_source
  parameters:
    stream_id: rit_agc
  states: {}
- name: virtual_source_0_0
  id: virtual_source
  parameters:
    stream_id: probe
  states: {}
- name: virtual_source_0_0_0
  id: virtual_source
  parameters:
    stream_id: rit_agc
  states: {}

connections:
- [analog_agc_xx_0, '0', analog_wfm_rcv_0, '0']
- [analog_agc_xx_0, '0', low_pass_filter_1, '0']
- [analog_const_source_x_0, '0', blocks_float_to_complex_0, '1']
- [analog_const_source_x_1, '0', qtgui_number_sink_0, '0']
- [analog_nbfm_rx_0, '0', blocks_multiply_const_vxx_1, '0']
- [analog_nbfm_rx_0, '0', blocks_selector_0, '4']
- [analog_nbfm_tx_0, '0', rational_resampler_xxx_2_0_0_0_0_0, '0']
- [analog_pll_refout_cc_0_0, '0', blocks_multiply_xx_0, '1']
- [analog_sig_source_x_0, '0', blocks_multiply_xx_0_0, '1']
- [analog_sig_source_x_0_0, '0', blocks_multiply_xx_0_0_0, '1']
- [analog_sig_source_x_0_0_0, '0', blocks_multiply_xx_0_0_0_0, '0']
- [analog_sig_source_x_1, '0', blocks_multiply_xx_1, '1']
- [analog_sig_source_x_2, '0', blocks_multiply_xx_2, '1']
- [analog_sig_source_x_3, '0', blocks_multiply_xx_3, '1']
- [analog_sig_source_x_3_0, '0', blocks_multiply_xx_3_0, '1']
- [analog_sig_source_x_4, '0', blocks_multiply_xx_4, '1']
- [analog_sig_source_x_5, '0', blocks_multiply_xx_5, '1']
- [analog_sig_source_x_6, '0', blocks_multiply_xx_6, '1']
- [analog_sig_source_x_6_0, '0', blocks_add_xx_2, '2']
- [analog_wfm_rcv_0, '0', blocks_selector_0, '1']
- [analog_wfm_tx_0, '0', rational_resampler_xxx_0, '0']
- [band_pass_filter_0, '0', blocks_selector_0, '0']
- [band_pass_filter_0_0, '0', blocks_selector_0, '1']
- [band_pass_filter_0_0_0, '0', blocks_multiply_xx_3_0, '0']
- [band_pass_filter_0_1, '0', blocks_multiply_xx_3, '0']
- [band_pass_filter_0_2, '0', blocks_multiply_const_vxx_0, '0']
- [band_pass_filter_1, '0', blocks_complex_to_real_0, '0']
- [band_pass_filter_2, '0', blocks_add_xx_1, '0']
- [band_pass_filter_2_0, '0', blocks_add_xx_1, '1']
- [blocks_add_const_vxx_0, '0', blocks_multiply_xx_2, '0']
- [blocks_add_xx_0, '0', blocks_multiply_const_vxx_2, '0']
- [blocks_add_xx_0, '0', qtgui_freq_sink_x_2, '0']
- [blocks_add_xx_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_add_xx_0, '0', rational_resampler_xxx_4, '0']
- [blocks_add_xx_1, '0', blocks_multiply_xx_0, '0']
- [blocks_add_xx_1_0, '0', blocks_multiply_const_vxx_0_0, '0']
- [blocks_add_xx_1_0_0, '0', rational_resampler_xxx_2_0_0_0_0, '0']
- [blocks_add_xx_2, '0', rational_resampler_xxx_2, '0']
- [blocks_complex_to_mag_squared_0, '0', blocks_integrate_xx_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', band_pass_filter_0_0, '0']
- [blocks_complex_to_real_0, '0', blocks_selector_0, '2']
- [blocks_complex_to_real_0_0, '0', blocks_selector_0, '3']
- [blocks_complex_to_real_2, '0', band_pass_filter_0, '0']
- [blocks_file_source_0_4_0, '0', blocks_throttle_1_0, '0']
- [blocks_file_source_1_0, '0', blocks_repeat_1, '0']
- [blocks_file_source_1_0_0, '0', digital_map_bb_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_0_0, '0']
- [blocks_float_to_complex_0, '0', band_pass_filter_0_1, '0']
- [blocks_float_to_complex_0, '0', low_pass_filter_1_0, '0']
- [blocks_head_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_integrate_xx_0, '0', blocks_nlog10_ff_0, '0']
- [blocks_multiply_const_vxx_0, '0', mmse_resampler_xx_0, '0']
- [blocks_multiply_const_vxx_0, '0', rational_resampler_xxx_5, '0']
- [blocks_multiply_const_vxx_0_0, '0', blocks_add_xx_0, '1']
- [blocks_multiply_const_vxx_0_0_0, '0', packet_rx_0, '0']
- [blocks_multiply_const_vxx_1, '0', blocks_null_sink_2, '0']
- [blocks_multiply_const_vxx_1, '0', rational_resampler_xxx_1, '0']
- [blocks_multiply_const_vxx_2, '0', blocks_null_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', iio_pluto_sink_0, '0']
- [blocks_multiply_const_vxx_2, '0', low_pass_filter_2, '0']
- [blocks_multiply_const_xx_1, '0', blocks_multiply_const_vxx_0_0_0, '0']
- [blocks_multiply_const_xx_1, '0', qtgui_const_sink_x_0, '0']
- [blocks_multiply_const_xx_1, '0', qtgui_freq_sink_x_0_2, '0']
- [blocks_multiply_const_xx_1, '0', qtgui_time_sink_x_1, '0']
- [blocks_multiply_const_xx_1, '0', rational_resampler_xxx_6, '0']
- [blocks_multiply_const_xx_1, '0', uhd_usrp_sink_0, '0']
- [blocks_multiply_xx_0, '0', blocks_complex_to_real_2, '0']
- [blocks_multiply_xx_0_0, '0', blocks_add_xx_1_0, '1']
- [blocks_multiply_xx_0_0, '0', blocks_selector_0_0_0, '1']
- [blocks_multiply_xx_0_0_0, '0', blocks_add_xx_1_0, '2']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_null_sink_5, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_probe_rate_0, '0']
- [blocks_multiply_xx_0_0_0_0, '0', blocks_selector_0_0_0, '3']
- [blocks_multiply_xx_1, '0', blocks_add_xx_1_0, '0']
- [blocks_multiply_xx_1, '0', blocks_selector_0_0_0, '2']
- [blocks_multiply_xx_2, '0', blocks_add_xx_1_0_0, '0']
- [blocks_multiply_xx_2, '0', blocks_selector_0_0, '1']
- [blocks_multiply_xx_3, '0', blocks_add_xx_1_0_0, '1']
- [blocks_multiply_xx_3, '0', blocks_selector_0_0, '2']
- [blocks_multiply_xx_3_0, '0', blocks_add_xx_1_0_0, '2']
- [blocks_multiply_xx_3_0, '0', blocks_selector_0_0, '3']
- [blocks_multiply_xx_4, '0', blocks_add_xx_0, '2']
- [blocks_multiply_xx_5, '0', blocks_add_xx_2, '0']
- [blocks_multiply_xx_6, '0', blocks_add_xx_2, '1']
- [blocks_nlog10_ff_0, '0', probe_signal, '0']
- [blocks_null_source_0, '0', low_pass_filter_0, '0']
- [blocks_null_source_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_null_source_0_0, '0', blocks_selector_0_0_0, '3']
- [blocks_null_source_1, '0', blocks_selector_0_0, '0']
- [blocks_null_source_1_0, '0', blocks_selector_0_0_0, '0']
- [blocks_null_source_2, '0', blocks_throttle_0, '0']
- [blocks_null_source_3, '0', blocks_throttle_1, '0']
- [blocks_null_source_4, '0', blocks_add_xx_0, '4']
- [blocks_null_source_5, '0', uhd_usrp_sink_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_repack_bits_bb_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_repack_bits_bb_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_file_sink_0_0, '0']
- [blocks_pdu_to_tagged_stream_0_1, '0', blocks_null_sink_0_0, '0']
- [blocks_probe_rate_0, rate, blocks_message_debug_0, print]
- [blocks_repack_bits_bb_0, '0', digital_map_bb_1, '0']
- [blocks_repack_bits_bb_0_0, '0', digital_map_bb_1_0, '0']
- [blocks_repeat_1, '0', root_raised_cosine_filter_1, '0']
- [blocks_selector_0, '0', band_pass_filter_0_2, '0']
- [blocks_selector_0_0, '0', rational_resampler_xxx_2_0_0_0, '0']
- [blocks_selector_0_0_0, '0', blocks_add_xx_0, '3']
- [blocks_stream_to_tagged_stream_0, '0', blocks_head_0, '0']
- [blocks_tagged_stream_multiply_length_0, '0', low_pass_filter_0_0, '0']
- [blocks_tagged_stream_mux_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, digital_crc32_async_bb_1, in]
- [blocks_throttle_0, '0', blocks_null_sink_1, '0']
- [blocks_throttle_1, '0', blocks_null_sink_3, '0']
- [blocks_throttle_1_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_unpacked_to_packed_xx_0, '0', digital_psk_mod_0, '0']
- [blocks_vector_source_x_2, '0', digital_map_bb_0, '0']
- [blocks_wavfile_source_0, '0', analog_nbfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', analog_wfm_tx_0, '0']
- [blocks_wavfile_source_0, '0', blocks_float_to_complex_0, '0']
- [dc_blocker_xx_0, '0', uhd_usrp_sink_0_0, '0']
- [digital_burst_shaper_xx_0, '0', pfb_arb_resampler_xxx_0, '0']
- [digital_chunks_to_symbols_xx_0, '0', mod_header, '0']
- [digital_chunks_to_symbols_xx_0_0, '0', mod_payload, '0']
- [digital_crc32_async_bb_1, out, fec_async_encoder_0, in]
- [digital_map_bb_0, '0', blocks_unpacked_to_packed_xx_0, '0']
- [digital_map_bb_1, '0', digital_chunks_to_symbols_xx_0, '0']
- [digital_map_bb_1_0, '0', digital_chunks_to_symbols_xx_0_0, '0']
- [digital_protocol_formatter_async_0, header, fec_async_encoder_0_0, in]
- [digital_protocol_formatter_async_0, payload, blocks_pdu_to_tagged_stream_0, pdus]
- [digital_psk_mod_0, '0', rational_resampler_xxx_3, '0']
- [fec_async_encoder_0, out, digital_protocol_formatter_async_0, in]
- [fec_async_encoder_0_0, out, blocks_pdu_to_tagged_stream_0_0, pdus]
- [freq_xlating_fir_filter_xxx_0, '0', blocks_complex_to_real_0_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', analog_nbfm_rx_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', virtual_sink_0, '0']
- [freq_xlating_fir_filter_xxx_1, '0', virtual_sink_0_0, '0']
- [iio_pluto_source_0, '0', low_pass_filter_0, '0']
- [iio_pluto_source_0, '0', qtgui_freq_sink_x_0, '0']
- [low_pass_filter_0, '0', analog_agc_xx_0, '0']
- [low_pass_filter_0_0, '0', blocks_multiply_const_xx_1, '0']
- [low_pass_filter_1, '0', freq_xlating_fir_filter_xxx_1, '0']
- [low_pass_filter_1_0, '0', blocks_add_const_vxx_0, '0']
- [low_pass_filter_2, '0', dc_blocker_xx_0, '0']
- [low_pass_filter_2, '0', uhd_usrp_sink_0_0, '0']
- [mmse_resampler_xx_0, '0', audio_sink_0_0, '0']
- [mmse_resampler_xx_0, '0', blocks_wavfile_sink_0_0, '0']
- [packet_rx_0, '1', blocks_null_sink_4, '0']
- [packet_rx_0, '1', qtgui_const_sink_x_0_0_0, '0']
- [packet_rx_0, '1', qtgui_freq_sink_x_0_0, '0']
- [packet_rx_0, pkt out, blocks_pdu_to_tagged_stream_0_1, pdus]
- [pfb_arb_resampler_xxx_0, '0', blocks_tagged_stream_multiply_length_0, '0']
- [qtgui_freq_sink_x_0, freq, soapy_source_0, command]
- [qtgui_freq_sink_x_0, freq, uhd_usrp_source_0, command]
- [rational_resampler_xxx_0, '0', blocks_multiply_xx_1, '0']
- [rational_resampler_xxx_1, '0', analog_nbfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', analog_wfm_tx_0, '0']
- [rational_resampler_xxx_1, '0', blocks_float_to_complex_0, '0']
- [rational_resampler_xxx_2, '0', blocks_multiply_xx_4, '0']
- [rational_resampler_xxx_2_0_0_0, '0', blocks_add_xx_0, '0']
- [rational_resampler_xxx_2_0_0_0_0, '0', blocks_multiply_xx_0_0_0, '0']
- [rational_resampler_xxx_2_0_0_0_0_0, '0', blocks_multiply_xx_0_0, '0']
- [rational_resampler_xxx_3, '0', blocks_multiply_xx_6, '0']
- [rational_resampler_xxx_4, '0', iio_pluto_sink_0, '0']
- [rational_resampler_xxx_5, '0', audio_sink_0_0, '0']
- [rational_resampler_xxx_6, '0', blocks_multiply_xx_0_0_0_0, '1']
- [root_raised_cosine_filter_0, '0', blocks_multiply_xx_5, '0']
- [root_raised_cosine_filter_1, '0', root_raised_cosine_filter_0, '0']
- [rtlsdr_source_0, '0', low_pass_filter_0, '0']
- [rtlsdr_source_0, '0', qtgui_freq_sink_x_0, '0']
- [rtlsdr_source_0, '0', qtgui_sink_x_0, '0']
- [rx_mod_header, '0', blocks_tagged_stream_mux_0, '0']
- [rx_mod_payload, '0', blocks_tagged_stream_mux_0, '1']
- [soapy_source_0, '0', low_pass_filter_0, '0']
- [soapy_source_0, '0', qtgui_freq_sink_x_0, '0']
- [soapy_source_0, '0', qtgui_sink_x_0, '0']
- [uhd_usrp_source_0, '0', low_pass_filter_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_sink_x_0, '0']
- [virtual_source_0, '0', analog_pll_refout_cc_0_0, '0']
- [virtual_source_0, '0', band_pass_filter_2, '0']
- [virtual_source_0, '0', band_pass_filter_2_0, '0']
- [virtual_source_0, '0', blocks_complex_to_mag_squared_0_0, '0']
- [virtual_source_0_0, '0', blocks_complex_to_mag_squared_0, '0']
- [virtual_source_0_0_0, '0', band_pass_filter_1, '0']
- [virtual_source_0_0_0, '0', freq_xlating_fir_filter_xxx_0, '0']

metadata:
  file_format: 1
